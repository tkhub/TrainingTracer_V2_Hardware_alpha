# Repository tkhub/TrainingTracer_V2_Hardware_alpha

File README.md:

[TraningTracer Ver.2](https://rt-net.jp/products/traning-tracer2/)
の勝手改造版です。

## 改造・改良箇所
* 改造箇所
  * 一般的な3端子レギュレータの端子配置(Vin-GND-Vout)への対応
    * [スーパー3端子レギュレータ](https://akizukidenshi.com/catalog/g/g107178/)が使用でき、高電圧なLiPoバッテリーに対応可能
  * 逆電圧による3端子レギュレータ破壊防止のDiを追加
  * 改造用に各種電源とI2Cのピンアウトを設定
  * ディスコンになったBMX055のかわりにBNO055を搭載可能
    * ショートピンの設定(ハンダ盛り)が必要
  * 自励式ブザーの代わりに圧電スピーカーを搭載可能でより多彩な情報を通知可能
    * 自励式ブザーを使用時は直流阻止コンデンサのC5をショートすること
  * I2Cディスプレイ用コネクタの設定
    * [0.96インチOLEDディスプレイ](https://akizukidenshi.com/catalog/g/g112031/)のような追加ディスプレイによりより多くの情報をユーザーに通知可能
  * 基板上にラインズレ量を測るスケールを追加
  * その他小変更
* 改良箇所
  * パイロットランプの追加
    * 電源入れっぱなしの防止
  * [バッテリー電圧計測のブレ対策にコンデンサC4を追加](https://github.com/rt-net/TrainingTracer_V2_Hardware/issues/1)
  * [回路図上のラベルとセンサの物理配置、ソフトの命名の整合性確保](https://github.com/rt-net/TrainingTracer_V2_Hardware/issues/2)
  * [プログラム書き込み中にモータが回転する問題の解決](https://github.com/rt-net/TrainingTracer_Hardware/issues/7)

## フォルダ構成

* 3d_cad_data
　トレーニングトレーサーの3DCADデータ
  STPファイルとIGSファイルで保存しています。
* 3d_print_parts
　トレーニングトレーサーの3Dプリント部品のデータ
  * TrainingTracer_Motor_Mount.stl
    トレーニングトレーサーのモータマウントの3Dモデルです。
  * TrainingTracerV2_Slider.stl
    トレーニングトレーサーのスライダーの3Dモデルです。
  * TrainingTracerV2_Wheel.stl
    トレーニングトレーサーのホイールの3Dモデルです。
* circuits
　トレーニングトレーサーの回路図とNucleoの追加工マニュアル
  * TrainingTracer
    * KiCadのプロジェクトフォルダ
  * old
    * TrainingTracerV2_circuit_rev1.0.pdf
    トレーニングトレーサーのメイン基板の回路図です。
    * TrainingTracer_marker_circuit.pdf
    トレーニングトレーサーのマーカーセンサ基板の回路図です。
  * TrainingTracer_PCB.pdf
    改造後の基板
  * TrainingTracer_SCH.pdf
    改造後の回路図
  * 出荷時のNucleoの追加工.pdf
    トレーニングトレーサーのNucleoボードに行った追加工の情報です。
    
## 開発について

本リポジトリはオープンソースですが、開発はオープンではありません。  
機能追加については社内のガイドラインを優先します。  
誤植や不具合の修正は常時受け付けています。詳しくは[コントリビューションガイドライン](https://github.com/rt-net/.github/blob/master/CONTRIBUTING.md)に従ってください。

## ライセンス

(C) 2020 RT Corporation \<support@rt-net.jp\>

各ファイルはライセンスがファイル中に明記されている場合、そのライセンスに従います。特に明記されていない場合は、Apache License, Version 2.0に基づき公開されています。  
ライセンスの全文は[LICENSE](./LICENSE)または[https://www.apache.org/licenses/LICENSE-2.0](https://www.apache.org/licenses/LICENSE-2.0)から確認できます。

## KiCad design circuits/TrainingTracer/TrainingTracer.kicad_pcb

Parts:
J11: BMX055/BNO055-1; PinSocket_1x04_P2.54mm_Vertical
J12: BMX055/BNO055-2; PinSocket_1x04_P2.54mm_Vertical
JP1: BMX_VCC/BNO_GND; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
JP2: BMX055_ON; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
PR1, PR2, PR3, PR4, PR5, PR6, PR7, PR8, PR9, PR10: LBR-127HLD; LED-AK_PTR_CE_p410xp254
R4, R8, R10, R12: 33; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5, R13: 75; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6, R7, R9, R11, R14, R15: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal

Connections:
+3.3V: J11.1, JP1.1 (A), JP2.2 (B), PR1.1 (A), PR1.4 (C), PR2.4 (C), PR3.4 (C), PR4.1 (A), PR4.4 (C), PR5.4 (C), PR6.1 (A), PR6.4 (C), PR7.4 (C), PR8.1 (A), PR8.4 (C), PR9.4 (C), PR10.4 (C), R5.1, R13.1; also elsewhere on the board
FLS: PR4.3 (E), PR5.3 (E), R9.1; also elsewhere on the board
FRS: PR6.3 (E), PR7.3 (E), R11.1; also elsewhere on the board
GND: J11.2, JP1.3 (B), PR2.2 (K), PR3.2 (K), PR5.2 (K), PR7.2 (K), PR9.2 (K), PR10.2 (K), R6.2, R7.2, R9.2, R11.2, R14.2, R15.2; also elsewhere on the board
LLS: PR1.3 (E), PR2.3 (E), R6.1; also elsewhere on the board
MLS: PR3.3 (E), R7.1; also elsewhere on the board
MRS: PR10.3 (E), R15.1; also elsewhere on the board
unnamed: J12.1, JP2.1 (A)
unnamed: J12.3, JP1.2 (C)
unnamed: PR1.2 (K), R4.1
unnamed: PR2.1 (A), R4.2
unnamed: PR3.1 (A), R5.2
unnamed: PR4.2 (K), R8.1
unnamed: PR5.1 (A), R8.2
unnamed: PR6.2 (K), R10.1
unnamed: PR7.1 (A), R10.2
unnamed: PR8.2 (K), R12.1
unnamed: PR9.1 (A), R12.2
unnamed: PR10.1 (A), R13.2
RRS: PR8.3 (E), PR9.3 (E), R14.1; also elsewhere on the board
SCL: J11.4; also elsewhere on the board
SDA: J11.3; also elsewhere on the board

Notes on the sheet:
改造箇所3：ディスコンセンサの置き換え対応(BMX055→BNO055)

Parts:
C1: C_Polarized; CP_Radial_D6.3mm_P2.50mm
C2: 0.33uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3, C4: 0.1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: LED_BLUE; LED_D3.0mm
D2: D_Small_Filled; D_A-405_P7.62mm_Horizontal; not fitted
J1: BATT+; SolderWire-0.75sqmm_1x01_D1.25mm_OD2.3mm
J2: BATT-; SolderWire-0.75sqmm_1x01_D1.25mm_OD2.3mm
J3, J4, J5, J6, J7, J8, J9, J10: Conn_01x01_Socket; SolderWire-0.25sqmm_1x01_D0.65mm_OD1.7mm
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 20k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R18: 0; jmp_15.24mm
SW1: SW_SPDT; Switch
U1: NJU7223F-33; TO-220-3_Vertical
U2: LM2931-3.3_TO220; TO-220-3_Vertical; not fitted

Connections:
+3.3V: C3.1, D2.2 (A), J3.1, J4.1, U1.1 (Vout), U2.3 (VO); also elsewhere on the board
+BATT: C1.1, J1.1, R18.1; also elsewhere on the board
BSEN: C4.1, R2.2, R3.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, D1.1 (K), J2.1, J7.1, J8.1, J9.1, J10.1, R3.2, U1.3 (GND), U2.2 (GND); also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed: R18.2, SW1.2 (B)
VCC: C2.1, D2.1 (K), J5.1, J6.1, R1.1, R2.1, SW1.3 (C), U1.2 (Vin), U2.1 (VI)

Notes on the sheet:
改造箇所1：汎用レギュレータ(M78AR033-0.5等)への対応
逆電圧防止Di(SBD推奨)
改良箇所1：パイロットランプ
改造箇所2：改造・テスト用ピンアウト
改良箇所2：バッテリー電圧計測値のズレ対策
一般的なピン配置のレギュレータ

Parts:
J18, J19: NUCLEO-F303K8; PinSocket_1x15_P2.54mm_Vertical

Connections:
+3.3V: J19.13, J19.14; also elsewhere on the board
AIN1: J18.2; also elsewhere on the board
AIN2: J18.15; also elsewhere on the board
BIN1: J18.13; also elsewhere on the board
BIN2: J18.14; also elsewhere on the board
BSEN: J19.6; also elsewhere on the board
BUZZER/SP: J18.5; also elsewhere on the board
FLS: J19.8; also elsewhere on the board
FRS: J19.9; also elsewhere on the board
GND: J18.4, J19.2; also elsewhere on the board
LHallA: J18.1; also elsewhere on the board
LHallB: J18.12; also elsewhere on the board
LLS: J19.7; also elsewhere on the board
MLS: J18.6; also elsewhere on the board
MRS: J18.9; also elsewhere on the board
RHallA: J19.11; also elsewhere on the board
RHallB: J19.12; also elsewhere on the board
RRS: J19.10; also elsewhere on the board
SCL: J18.8; also elsewhere on the board
SDA: J18.7; also elsewhere on the board
SW1: J18.10; also elsewhere on the board
SW2: J18.11; also elsewhere on the board

Notes on the sheet:
改良箇所4：ラベルの命名をソフト上の命名と統一

Parts:
J14: DRV8835_1; PinSocket_1x06_P2.54mm_Vertical
J15: DRV8835_2; PinSocket_1x06_P2.54mm_Vertical
J16: PINHD-1x6(MOTOR-L); PinSocket_1x06_P2.54mm_Vertical
J17: PINHD-1x6(MOTO-R); PinSocket_1x06_P2.54mm_Vertical
R16, R17: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal

Connections:
+3.3V: J14.1, J14.2, J16.5, J17.5; also elsewhere on the board
+BATT: J15.1; also elsewhere on the board
/motors/AOUT1: J15.2, J16.6
/motors/AOUT2: J15.3, J16.1
/motors/BOUT1: J15.4, J17.6
/motors/BOUT2: J15.5, J17.1
AIN1: J14.3; also elsewhere on the board
AIN2: J14.4, R16.1; also elsewhere on the board
BIN1: J14.5; also elsewhere on the board
BIN2: J14.6, R17.1; also elsewhere on the board
GND: J15.6, J16.2, J17.2, R16.2, R17.2; also elsewhere on the board
LHallA: J16.3; also elsewhere on the board
LHallB: J16.4; also elsewhere on the board
RHallA: J17.3; also elsewhere on the board
RHallB: J17.4; also elsewhere on the board

Notes on the sheet:
改良箇所3：マイコンブート前の暴走対策

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C5: 1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
J13: OLED_DSP; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J20: SDL; PinHeader_1x01_P1.00mm_Vertical
J21: SCL; PinHeader_1x01_P1.00mm_Vertical
SW2: SW1; SW_PUSH_6mm_H7.3mm
SW3: SW2; SW_PUSH_6mm_H7.3mm

Connections:
+3.3V: J13.3; also elsewhere on the board
BUZZER/SP: C5.1; also elsewhere on the board
GND: BZ1.2 (-), J13.4, SW2.1, SW3.1; also elsewhere on the board
unnamed: BZ1.1 (+), C5.2
SCL: J13.2, J21.1; also elsewhere on the board
SDA: J13.1, J20.1; also elsewhere on the board
SW1: SW2.2; also elsewhere on the board
SW2: SW3.2; also elsewhere on the board

Notes on the sheet:
改造箇所6： 圧電素子時の場合はコンデンサ 自励ブザーの場合はコンデンサをジャンパでショート
改造箇所5：OLEDディスプレイ用のコネクタ追加
改造箇所4：汎用のI2Cピンアウト

Board: 2 copper layers, 131.0 x 100.0 mm, 64 parts (14 on the bottom side), 43 nets.

## Commit log

2025-12-29 回路作成
2026-01-03 回路完成
2026-01-03 回路図のPDF出力
2026-01-03 PCBのPDF出力
2026-01-04 ゴミファイル削除。PDFの移動。
2026-01-04 バックアップファイル追跡の解除
2026-01-04 gitignore編集
2026-01-04 Update README with hardware modification details
    改造・改良箇所の明記
2026-01-04 改造箇所の漏れを追加 (+その他)
2026-01-04 PCB後進
